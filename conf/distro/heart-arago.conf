## conf/distro/heart-arago.conf
```bitbake
require conf/distro/arago.conf

DISTRO = "heart-arago"
DISTRO_NAME = "Heartbeat Arago"
DISTRO_VERSION = "2021.09"


IMAGE_INSTALL_append = " ntpdate"
```
